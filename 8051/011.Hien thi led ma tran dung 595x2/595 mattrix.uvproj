# Keil uVision project 595 mattrix.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 595 mattrix +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 595.c
