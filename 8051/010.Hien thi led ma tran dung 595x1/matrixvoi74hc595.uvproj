# Keil uVision project matrixvoi74hc595.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: matrixvoi74hc595 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: matrix74hc595.c
